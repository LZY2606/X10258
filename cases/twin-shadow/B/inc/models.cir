.INC ./amp.cir
.INC ./amp-shadow.cir
